# Keil uVision project GSH.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: GSH-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Application\ADC;.\Application\Button;.\Application\EEPROM;.\Application\LCD1602;.\Application\SYS;.\Application\Thermistortables;.\Application\Timer;.\Application\UART;.\Application
  group Source Group 1
    ./: main.c
    ./Application/SYS/: Sys.c
    ./Application/EEPROM/: EEPROM.c
    ./Application/Button/: Key.c
    ./Application/LCD1602/: LCD1602.c
    ./Application/UART/: Uart.c
    ./Application/ADC/: STC12(ADC flag).c
    ./Application/: Task.c
    ./Application/Thermistortables/: Thermistortables.c
    ./Application/Timer/: Timer.c
